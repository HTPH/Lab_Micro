 ORG 0000H
 JMP 0100H

 ORG 0100H

MOV A,#7CH ;B
 CALL DISPLAY

   MOV A,#7DH ;6
 CALL DISPLAY

 MOV A,#07H ;7
 CALL DISPLAY

 MOV A,#4FH ;3
 CALL DISPLAY

 MOV A,#3FH  ;0
 CALL DISPLAY

 MOV A,#07H ;7
 CALL DISPLAY

  MOV A,#66H ;4
 CALL DISPLAY

  MOV A,#06H ;1
 CALL DISPLAY

 JMP 0100H


DISPLAY:
 CPL A
 MOV P1,A
 RET

 END
